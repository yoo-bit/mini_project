Commit message: 100 squre plane

File: plane100.urdf (robot description, URDF)
Before this commit: robot plane2, 1 links, 0 joints
Links:
- removed link planeLink
- added link baseLink, mass .0; collision box size=200 200 0.001; visual mesh filename=plane100.obj scale=1 1 1
